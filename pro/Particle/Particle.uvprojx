# Keil uVision project Particle.uvprojx, settings and files
target Particle (ARM-ADS)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Particle
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\inc;..\..\lib\stm32\inc;..\..\lib\cmsis\inc;..\..\board\inc;..\..\inc\xtos
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: main.c interrupts.c
  group libstm32
    ../../lib/stm32/src/: startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c
  group board
    ../../board/src/: led.c usart4.c
  group xtos
    ../../xtos/: xtos.c xtos_asm.s
